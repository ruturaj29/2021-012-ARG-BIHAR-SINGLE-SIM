# Keil uVision project MAH_ST0301.uvprojx, settings and files
target LPC17xx FLASH (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.6.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MAH_ST0301 +hex
  AfterMake: fromelf --bin Objects\MAH_ST0301.axf --output FIRMWARE.bin
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Core\CM3\CoreSupport;.\Core\CM3\DeviceSupport\NXP\LPC17xx;.\DRIVERS\inlcude;.\RTE\Device\LPC1768;.\DRIVERS\fatfs;.\DRIVERS\minIni-master\dev;.\DRIVERS\USB\Host;.\DRIVERS\USB\MassStorage;.\DRIVERS\USB\USB_Include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Drivers
    ./DRIVERS/source/: adc.c convert.c delay.c extintr.c gpio.c gprs.c LCD_Scroll.c lcd.c lpc17xx_clkpwr.c lpc17xx_wdt.c rtc.c spi.c uart.c lpc17xx_libcfg_default.c rain.c mmc_176x_ssp.c eeprom.c SMS.c bod.c systick.c log.c IOExtInt.c softi2c.c
  group Main
    ./: main.c
  group fatfs
    ./DRIVERS/fatfs/: ff.c diskio.c
    ./DRIVERS/fatfs/option/: ccsbcs.c syscall.c unicode.c
  group minIni
    ./DRIVERS/minIni-master/dev/: minIni.c
  group USB
    ./DRIVERS/USB/Host/: usbhost_lpc17xx.c
    ./DRIVERS/USB/MassStorage/: usbhost_ms.c
    ./DRIVERS/USB/USB_Disk_IO/: USB_176x_DiskIO.c
software components: CMSIS:CORE 5.3.0, Device:Startup 1.0.0
